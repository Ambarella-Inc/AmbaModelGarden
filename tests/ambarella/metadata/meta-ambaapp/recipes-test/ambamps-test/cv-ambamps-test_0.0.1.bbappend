inherit externalsrc
EXTERNALSRC = "${ENV_TOP_DIR}/unit_test/private/ambamps"
EXTERNALSRC_BUILD = "${ENV_TOP_DIR}/unit_test/private/ambamps"
